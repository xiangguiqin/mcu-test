# Keil uVision project FT32F030xx.uvprojx, settings and files
target FT32F030xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FT32F030CBATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FT32F030xx +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -c "$L@L.axf" --output "$L@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\USER;..\USER\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CMSIS;..\FT32F0xx_Driver\Inc;..\rt-thread\include;..\rt-thread\include\libc;..\rt-thread\bsp;..\GSV\userapp\stm32f030cc_gsv2k11_ffc_gsv\apps;..\GSV\kapi;..\GSV\uapi\gsv2k11_r1_reg;..\GSV\uapi;..\GSV\userbsp\keil\stm32f030cc_gsv2k11_ffc_gsv;..\USER\soft_i2c;..\USER\aw2013;..\USER\fpga2mcu_uart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group USER
    ../USER/: main.c ft32f0xx_it.c system_ft32f0xx.c
    ../USER/LED/: led.c
    ../USER/soft_i2c/: soft_i2c.c
    ../USER/aw2013/: aw2013.c
    ../USER/fpga2mcu_uart/: fpga2mcu_uart.c
  group CMSIS
    ../CMSIS/: startup_ft32f030x8.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group FT32F0xx_Driver
    ../FT32F0xx_Driver/Src/: ft32f0xx_adc.c ft32f0xx_comp.c ft32f0xx_crc.c ft32f0xx_crs.c ft32f0xx_dac.c ft32f0xx_debug.c ft32f0xx_div.c ft32f0xx_dma.c ft32f0xx_exti.c ft32f0xx_flash.c ft32f0xx_gpio.c ft32f0xx_i2c.c ft32f0xx_iwdg.c ft32f0xx_misc.c ft32f0xx_opa.c ft32f0xx_pwr.c ft32f0xx_rcc.c ft32f0xx_rtc.c ft32f0xx_spi.c ft32f0xx_syscfg.c ft32f0xx_tim.c ft32f0xx_usart.c ft32f0xx_wwdg.c
  group RTT/kernel
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RTT/cpu
    ../rt-thread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group RTT/board
    ../rt-thread/bsp/: board.c rtconfig.h
  group GSV/apps
    ../GSV/userapp/stm32f030cc_gsv2k11_ffc_gsv/apps/: av_common.c av_edid_manage.c av_event_handler.c av_irda_cmd.c av_key_cmd.c av_main.c av_uart_cmd.c
  group GSV/kapi
    ../GSV/kapi/: kapi.c kapi_debug_info.c kernel_fsm.c kernel_status_update.c uapi_function_mapper.c
  group GSV/uapi
    ../GSV/uapi/: gsv2k11.c hal.c uapi.c
  group GSV/userbsp
    ../GSV/userbsp/keil/stm32f030cc_gsv2k11_ffc_gsv/: bsp.c
software components: CMSIS:CORE 5.5.0
